ORG 00H
MAIN:
	MOV R0, #10000000B
	MOV R4, #01111111B
	MOV R1, #06H
	CALL R_LOOP
	MOV R1, #07H
	CALL L_LOOP
	JMP MAIN

R_LOOP:
	MOV R5, #250
	MOV P1, R4
	CALL DELAY
	MOV A, R0
	RR A
	MOV R0, A
	CPL A
	MOV R4, A
	MOV A, R1
	DEC R1
	JNZ R_LOOP
	RET

L_LOOP:
	MOV R5, #250
	MOV P1, R4
	CALL DELAY
	MOV A, R0
	RL A
	MOV R0, A
	CPL A
	MOV R4, A
	MOV A, R1
	DEC R1
	JNZ L_LOOP
	RET

DELAY:
	MOV R3,#255
	DJNZ R3,$
	MOV R3,#255
	DJNZ R3,$
	DJNZ R5,DELAY
	RET
	
END